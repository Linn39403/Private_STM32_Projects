# Keil uVision project NaturalTinyShell.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L073_BL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_UART2,USE_BLUE
  c include: .\Inc;.\Drivers\STM32L0xx_HAL_Driver\Inc;.\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\Drivers\CMSIS\Include;.\Boot\Inc;.\Drivers;.\RingBuffer;.\NtShell\src\lib\core;.\NtShell\src\lib\util
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./Startup/: startup_stm32l073xx.s
  group Drivers/BSP
    ./Drivers/: com.c stm32l0xx_nucleo.c
  group Applicaiton/User
    ./Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L07xx_HAL_Drives
    ./Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_gpio.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_ll_rcc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c
  group Drivesr/CMSIS
    ./Src/: system_stm32l0xx.c
  group NtShell
    ./NtShell/src/lib/core/: ntlibc.c ntshell.c text_editor.c text_history.c vtrecv.c vtsend.c
    ./NtShell/src/lib/util/: ntopt.c ntstdio.c
    ./Src/: usrcmd.c
software components: CMSIS:CORE 5.2.0
