# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c misc: --C99
  c include: ../Inc;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers/STM32L4xx_HAL_Driver/Inc;..\Drivers/BSP/B-L475E-IOT01;..\Drivers/BSP/Components/Common;..\Drivers/BSP/Components/hts221;..\Drivers/BSP/Components/lps22hb;..\Drivers/BSP/Components/lis3mdl;..\Drivers/BSP/Components/lsm6dsl;..\uCProbe_Target\Communication\Generic\Source;..\uc-CPU\ARM-Cortex-M4\RealView;..\uc-CPU;..\uc-CPU\Cfg\Template;..\uC-LIB\Cfg\Template;..\uC-LIB;..\uCProbe_Target\Communication\Generic\RS-232\Source;..\uCProbe_Target\Communication\Generic\Cfg\Template\;..\uCProbe_Target\Communication\Generic\RS-232\Ports\ST\STM32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/BSP/B-L475E-IOT01
    ../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_qspi.c stm32l475e_iot01_tsensor.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_gyro.c stm32l475e_iot01_magneto.c stm32l475e_iot01_accelero.c stm32l475e_iot01_psensor.c
  group Example/MDK-ARM
    ./: startup_stm32l475xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_qspi.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c sensors.c qspi.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../Drivers/BSP/Components/hts221/: hts221.c
    ../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group uCProbe/Target/Communication/Generic/Cfg/Template
    ../uCProbe_Target/Communication/Generic/Cfg/Template/: probe_com_cfg.h
  group uCProbe/Target/Communication/Generic/OS
    ../uCProbe_Target/Communication/Generic/OS/None/: probe_com_os.c
  group uCProbe/Target/Communication/Generice/RS-232
    ../uCProbe_Target/Communication/Generic/RS-232/OS/None/: probe_rs232_os.c
    ../uCProbe_Target/Communication/Generic/RS-232/Ports/ST/STM32/: probe_rs232c.c probe_rs232c.h probe_rs232c_cmsis.c
    ../uCProbe_Target/Communication/Generic/RS-232/Source/: probe_rs232.c probe_rs232.h
  group uCProbe/Target/Communication/Generice/Source
    ../uCProbe_Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uCProbe\uc-CPU\ARM-Cortex-M4\RealView
    ../uc-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../uC-LIB/: lib_mem.c
software components: CMSIS:CORE 4.3.0
